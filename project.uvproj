# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: project
  c flags: Optimize=8 SizeSpeed=1
  c include: .\SYSTEM;.\USER;.\USER\delay;.\HARDWARE;.\HARDWARE\LED
  group SYSTEM
    ./SYSTEM/: STARTUP.A51
  group USER
    ./USER/: main.c
    ./USER/delay/: delay.c
  group HARDWARE
    ./HARDWARE/: keep.c
    ./HARDWARE/LED/: led.c
